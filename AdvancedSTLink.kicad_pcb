# Repository KisonHe/AdvancedJLink

## KiCad design AdvancedSTLink.kicad_pcb

Parts:
C1, C2: 33pF; C_0402_1005Metric
C3, C8, C9, C10, C11, C15, C18: 100nF; C_0402_1005Metric
C4: 1uF; C_0402_1005Metric
C5: 4.7uF; C_0603_1608Metric
C13, C14: 2.2uF; C_0402_1005Metric
C20, C21: 10uf; C_0805_2012Metric; LCSC C15850
C23: 0.1uF/50V; C_0603_1608Metric
D1: LED_Red; LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder; LCSC C2286
D2: LED_Yellow; LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder; LCSC C72038
D6: LED_Blue; LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder; LCSC C72041
FB1: Ferrite_Bead_Small; L_0805_2012Metric
H1, H2, H3, H4: MountingHole_Pad; MountingHole_2.2mm_M2_Pad_Via
J1: Conn_01x03; PinHeader_1x03_P2.54mm_Vertical
J2: Conn_01x02_Pin; PinHeader_1x02_P2.54mm_Vertical
J3: Conn_01x06; JLinkDebugSWDO
J4: USB_C_Receptacle_USB2.0; USB_C_Receptacle_HRO_TYPE-C-31-M-12; LCSC C165948
J5: Conn_01x05; JLinkSWDNonThroughHole
Q1: S8050; SOT-23(SOT-23-3); LCSC C2146
R1, R11, R12, R13, R14, R15, R18: 100; R_0402_1005Metric
R2, R3: 10k; R_0402_1005Metric
R4, R5: 5.1k; R_0402_1005Metric
R6: 2.2k; R_0402_1005Metric
R7: 3.9k; R_0402_1005Metric
R8: 3.3k; R_0402_1005Metric
R9: 1.5k; R_0402_1005Metric
R10: 4.7k; R_0402_1005Metric
R17: 100k; R_0402_1005Metric
R19, R20, R21: 6.8K; R_0402_1005Metric
SW2: SW_Push; SW_SPST_CK_RS282G05A3; LCSC C557592
U1: STM32F205RETx; LQFP-64_10x10mm_P0.5mm
U2: XC6206P332MR; SOT-23(SOT-23-3); LCSC C5446
U3, U5, U6, U7: USBLC6-2SC6; SOT-23-6; LCSC C15999
U4: SPX1117-3.3; SOT-223-3_TabPin2; LCSC C6862
Y1: X322512MSB4SI; Crystal_SMD_3225-4Pin_3.2x2.5mm; LCSC C9002

Connections:
+3V3: C5.1, C8.1, C9.1, C10.1, C11.1, C18.1, D1.2 (A), D2.2 (A), J5.1, U1.1 (VBAT), U1.13 (VDDA), U1.19 (VDD), U1.32 (VDD), U1.48 (VDD), U1.64 (VDD), U2.2 (VO), U5.5 (VBUS), U6.5 (VBUS), U7.5 (VBUS)
GND: C1.2, C2.1, C3.1, C4.2, C5.2, C8.2, C9.2, C10.2, C11.2, C13.1, C14.2, C15.2, C18.2, C20.2, C21.2, C23.2, D6.1 (K), H1.1, H2.1, H3.1, H4.1, J1.2, J3.4, J4.A1 (GND), J4.A12 (GND), J4.B1 (GND), J4.B12 (GND), J4.S1 (SHIELD), J5.4, Q1.2 (E), R2.1, R4.1, R5.1, R17.2, SW2.1, U1.12 (VSSA), U1.18 (VSS), U1.63 (VSS), U2.1 (GND), U3.2 (GND), U4.1 (GND), U5.2 (GND), U6.2 (GND), U7.2 (GND), Y1.2, Y1.4
LED1: R7.2, U1.29 (PB10)
LED2: R8.2, U1.30 (PB11)
unnamed: D1.1 (K), R7.1
unnamed: D2.1 (K), R8.1
unnamed: D6.2 (A), R9.2
unnamed: C21.1, J2.2, U4.2 (VO)
unnamed: J4.A5 (CC1), R4.2
unnamed: J4.B5 (CC2), R5.2
unnamed: Q1.1 (B), R10.1
unnamed: Q1.3 (C), R6.1, R21.1
unnamed: R17.1, U1.60 (BOOT0)
unnamed: R11.2, U1.41 (PA8)
unnamed: R14.2, U1.28 (PB2)
unnamed: R1.2, U1.35 (PB14)
unnamed: R2.2, R3.2, U1.8 (PC0)
unnamed: C2.2, U1.5 (PH0), Y1.3
unnamed: C1.1, U1.6 (PH1), Y1.1
unnamed: C13.2, U1.31 (VCAP_1)
unnamed: C14.1, U1.47 (VCAP_2)
unnamed: C4.1, FB1.1, U2.3 (VI)
RST2: U1.43 (PA10)
RST_PULL: R10.2, U1.61 (PB8)
RST_SENSE: R20.1, U1.25 (PC5)
STM_NRST: C3.2, J5.5, U1.7 (NRST)
STM_SWCLK: J5.3, U1.49 (PA14)
STM_SWDIO: J5.2, U1.46 (PA13)
TCK1: R12.1, U1.21 (PA5), U1.34 (PB13), U1.37 (PC6)
TCK2: R13.1, U1.40 (PC9)
TDO: R19.1, U1.36 (PB15), U1.38 (PC7)
TMS1: R18.1, U1.22 (PA6)
TMS2: R15.1, U1.23 (PA7)
T_NRST_I: R20.2, R21.2, U5.1 (IO1)
T_NRST_O: C23.1, J3.5, SW2.2, U5.6 (IO1)
T_SWCLK_I: R12.2, R13.2, U6.6 (IO1)
T_SWCLK_O: J3.3, U6.1 (IO1)
T_SWDIO_I: R15.2, R18.2, U6.4 (IO2)
T_SWDIO_O: J3.2, U6.3 (IO2)
T_SWO_I: R19.2, U5.3 (IO2)
T_SWO_O: J3.6, U5.4 (IO2)
USB_DN: U1.44 (PA11), U3.1 (IO1)
USB_DP: U1.45 (PA12), U3.3 (IO2)
USB_IN_DN: J4.A7 (D-), J4.B7 (D-), U3.6 (IO1)
USB_IN_DP: J4.A6 (D+), J4.B6 (D+), U3.4 (IO2)
VBUS: C20.1, FB1.2, J4.A4 (VBUS), J4.A9 (VBUS), J4.B4 (VBUS), J4.B9 (VBUS), U3.5 (VBUS), U4.3 (VI)
VCOM-JLinkRX: R14.1, U7.6 (IO1)
VCOM-JLinkTX: R1.1, R11.1, U7.4 (IO2)
VCOM-RX: J1.3, U7.1 (IO1)
VCOM-TX: J1.1, U7.3 (IO2)
V_OUT_3.3: C15.1, J2.1, J3.1, R3.1, R6.2, R9.1

Notes on the sheet:
对外电源

Board: 4 copper layers, 59 parts (0 on the bottom side), 50 nets, no tracks yet.

## Commit log

2020-04-17 Initial commit.
2020-04-17 Add ESP32 compability.
2020-05-19 Update JLink
2020-05-20 ESD diodes
2020-05-20 remove redundant tvs, layout
2020-05-21 fabrication version
2020-06-11 Rev 2
2020-06-11 Put components.
2020-06-11 Layout.
2020-06-12 DRC fixes
2020-06-12 Enhance grounding.
2020-06-12 Add teardrops.
2020-06-12 Enlarge holes.
2020-06-14 Rearrange RST.
2020-06-14 Sch.
2020-06-15 correct fabrication version
2020-06-15 Change DCDC design.
2020-06-15 Layout optimizations.
2020-06-15 Fixes.
2020-06-15 Move ESD.
2020-06-15 Fix a wire.
2020-06-15 Add teardrops
2020-06-23 Update gitignore.
2020-06-23 Update.
2020-06-26 Production.
2020-07-02 Final version.
2023-06-19 Change pins to 2.54, Add CH340
2023-06-19 Remove V5 files
2023-06-19 Remove CH340, use VCOM
2023-06-20 Change 3V3 out DCDC to SY8032E
2023-06-20 更换排阻为0402, 去除Ref丝印，修正VCOM提示丝印方向
2023-12-23 增加一个hub
2023-12-27 更新原理图
2023-12-27 改正电源, 改正电阻值, 改正上拉
2023-12-27 更新原理图以及layout
